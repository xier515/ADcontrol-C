# Keil uVision project controller.uvproj, settings and files
target Controller (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\SYSTEM\delay;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\RS485;..\HARDWARE\12864;..\SYSTEM\timer;..\Protocol;..\SYSTEM\iwdog;..\HARDWARE\DS1302;..\Protocol;..\HARDWARE\shtc1;..\HARDWARE\STMFLASH;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c logic.c pre_send.c messagebox.c action.c
    ../HARDWARE/12864/: Show.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/12864/: 12864.c
    ../HARDWARE/DS1302/: DS1302.c Clock.c
    ../HARDWARE/shtc1/: shtc1.c i2c_hal.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/iwdog/: iwdog.c
    ../SYSTEM/: debug.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_flash.c
  group Instructions
    ../: readme.txt
  group Protocol
    ../Protocol/: OldXinfeng.c DME3000.c communication.c
